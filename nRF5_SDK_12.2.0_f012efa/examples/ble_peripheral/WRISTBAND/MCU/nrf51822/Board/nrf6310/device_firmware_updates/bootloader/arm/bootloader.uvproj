# Keil uVision project bootloader.uvproj, settings and files
target dfu_dual_bank_hci (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: bootloader +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER,BOARD_NRF6310, BOOTLOADER_BANKED
  c misc: --c99
  c include: ..\include;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\ble\softdevice;..\
  memory RVCT4: ROM 0x3c800 size 0x3400
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ./../../../../../Source/templates/: system_nrf51.c
    ../: arm_startup_nrf51.s
  group Source Code
    ./../: main.c
    ../: dfu_dual_bank.c dfu_single_bank.c bootloader.c bootloader_util_arm.c
  group Services
    ../../../../../Source/ble/ble_services/: ble_dfu.c
  group Libraries
    ../../../../../Source/ble/: ble_flash.c
    ../../../../../Source/nrf_nvmc/: nrf_nvmc.c
    ../../../../../Source/app_common/: app_timer.c app_scheduler.c app_gpiote.c app_button.c crc16.c
  group HCI Transport
    ../: dfu_transport_serial.c
    ../../../../../Source/app_common/: hci_transport.c hci_slip.c hci_mem_pool.c app_uart.c
  group BLE Transport
    ../: dfu_transport_ble.c
    ../../../../../Source/ble/: ble_conn_params.c ble_advdata.c ble_stack_handler.c ble_radio_notification.c
    ../../../../../Source/ble/ble_services/: ble_srv_common.c
target dfu_single_bank_hci (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: as above
  output: bootloader +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER,BOARD_NRF6310, BOOTLOADER_BANKED
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x3c800 size 0x3400
  memory RVCT9: RAM 0x20002000 size 0x2000
target dfu_dual_bank_ble (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: as above
  output: bootloader +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER,BOARD_NRF6310, BOOTLOADER_BANKED
  c misc: --c99
  c include: ..\include;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\ble\softdevice
  memory RVCT4: ROM 0x3c800 size 0x3400
  memory RVCT9: RAM 0x20002000 size 0x2000
